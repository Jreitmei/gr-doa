options:
  parameters:
    author: jreitmei
    generate_options: no_gui
    generator_class_name: PythonNoGuiGenerator
    generator_module: gnuradio.grc.workflows.python_nogui
    id: calculate_phase_sync_accuracy
    output_language: python
    title: calculate_phase_sync_accuracy
  states: {}

blocks:
- name: corrected_phase_offsets_file_name
  id: variable
  parameters:
    value: os.path.join(input_variables.DirectoryConfigFiles, input_variables.CorrectedPhaseOffsets)
  states: {}
- name: input_variables
  id: variable_struct
  parameters:
    comment: |-
      input_variables: 
      Contains all the user-defined variables.
    field0: SampleRate
    field1: ToneFreq
    field10: Samples2FindMax
    field2: CenterFreq
    field3: NumArrayElements
    field4: Gain
    field5: RxAddr
    field6: DirectoryConfigFiles
    field7: RelativePhaseOffsets
    field8: CorrectedPhaseOffsets
    field9: SkipAhead
    value0: 1e6
    value1: 10e3
    value10: 2**11
    value2: 462e6
    value3: '4'
    value4: '60'
    value5: '"addr=10.88.136.34"'
    value6: '"/tmp"'
    value7: '"measure_relative_phase_offsets_446.cfg"'
    value8: '"measure_corrected_phase_offsets_446.cfg"'
    value9: 2**13
  states: {}
- name: rel_phase_offsets_file_name
  id: variable
  parameters:
    value: os.path.join(input_variables.DirectoryConfigFiles, input_variables.RelativePhaseOffsets)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: doa_findmax_and_save_0
  id: doa_findmax_and_save
  parameters:
    config_filename: corrected_phase_offsets_file_name
    num_inputs: input_variables.NumArrayElements-1
    samples_to_findmax: input_variables.Samples2FindMax
  states: {}
- name: doa_phase_correct_hier_0
  id: doa_phase_correct_hier
  parameters:
    config_filename: rel_phase_offsets_file_name
    num_ports: input_variables.NumArrayElements
  states: {}
- name: doa_phase_offset_est_0
  id: doa_phase_offset_est
  parameters:
    n_skip_ahead: input_variables.SkipAhead
    num_inputs: input_variables.NumArrayElements
  states: {}
- name: doa_x440_usrp_source_0
  id: doa_x440_usrp_source
  parameters:
    addresses: input_variables.RxAddr
    center_freq: input_variables.CenterFreq
    device_args: master_clock_rate=200e6
    gain: input_variables.Gain
    samp_rate: input_variables.SampleRate
    sources: input_variables.NumArrayElements
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import os
  states: {}

connections:
- [doa_phase_correct_hier_0, '0', doa_phase_offset_est_0, '0']
- [doa_phase_correct_hier_0, '1', doa_phase_offset_est_0, '1']
- [doa_phase_correct_hier_0, '2', doa_phase_offset_est_0, '2']
- [doa_phase_correct_hier_0, '3', doa_phase_offset_est_0, '3']
- [doa_phase_offset_est_0, '0', doa_findmax_and_save_0, '0']
- [doa_phase_offset_est_0, '1', doa_findmax_and_save_0, '1']
- [doa_phase_offset_est_0, '2', doa_findmax_and_save_0, '2']
- [doa_x440_usrp_source_0, '0', doa_phase_correct_hier_0, '0']
- [doa_x440_usrp_source_0, '1', doa_phase_correct_hier_0, '1']
- [doa_x440_usrp_source_0, '2', doa_phase_correct_hier_0, '2']
- [doa_x440_usrp_source_0, '3', doa_phase_correct_hier_0, '3']

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-979-g1055cd27
